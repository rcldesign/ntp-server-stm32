# Repository rcldesign/ntp-server-stm32 (continued)

## KiCad design hardware/ntp-server-stm32/ntp-server-stm32.kicad_pcb (continued)

Schematic: PoE.kicad_sch

Parts:
C3: 1nF; C_0402_1005Metric; TOLERANCE 5%; VOLTAGE 50V; MANUFACTURER_PART_NUMBER C0402C102J5GECAUTO; DIGIKEY_PART_NUMBER 399-C0402C102J5GECAUTOCT-ND
C4, C5, C12: 0.1uF; C_0402_1005Metric; TOLERANCE 10%; VOLTAGE 16V; MANUFACTURER_PART_NUMBER GCM155R71C104KA55D; DIGIKEY_PART_NUMBER 490-4759-1-ND
C6: 1nF; C_0402_1005Metric; TOLERANCE 5%; VOLTAGE 100V; MANUFACTURER_PART_NUMBER C0402C102K1GECAUTO; DIGIKEY_PART_NUMBER 399-17168-1-ND
C7, C9: 1uF; C_0805_2012Metric; TOLERANCE 10%; VOLTAGE 100V; MANUFACTURER_PART_NUMBER 08051C105K4T2A; DIGIKEY_PART_NUMBER 478-KAM21KR72A105KUCT-ND
C8: 0.1uF; C_0603_1608Metric; TOLERANCE 10%; VOLTAGE 100V; MANUFACTURER_PART_NUMBER GCJ188R72A104KA01D; DIGIKEY_PART_NUMBER 490-13420-1-ND
C10: 10uF; KCM55QR72A106KH01L; TOLERANCE 10%; VOLTAGE 100V; MANUFACTURER_PART_NUMBER KCM55QR72A106KH01L; DIGIKEY_PART_NUMBER 490-KCM55QR72A106KH01LCT-ND
C11: 47pF; C_0402_1005Metric; TOLERANCE 5%; VOLTAGE 100V; MANUFACTURER_PART_NUMBER GA0402A470JXBAP31G; DIGIKEY_PART_NUMBER 720-GA0402A470JXBAP31GCT-ND
CR1: SMCJ58A; DO214AC_LTF; MANUFACTURER_PART_NUMBER SMCJ58A; DIGIKEY_PART_NUMBER SMCJ58ALFCT-ND
D1: BAV70LT1G; SOT-23-3; MOUSER_PART_NUMBER 863-BAV70LT1G
D2, D3: DF6A6.8FUT1G; SOT-363_SC-70-6; MANUFACTURER_PART_NUMBER DF6A6.8FUT1G; DIGIKEY_PART_NUMBER DF6A6.8FUT1GOSCT-ND
D4: BZX84C12; SOT-23-3; MANUFACTURER_PART_NUMBER BZX84C12LT1G; DIGIKEY_PART_NUMBER BZX84C12LT1GOSCT-ND
Q1, Q4, Q5: BC847W; SOT-323_SC-70; MANUFACTURER_PART_NUMBER BC847W,135; DIGIKEY_PART_NUMBER 1727-BC847W,135CT-ND
Q2: FDMC8622; 8-PowerWDFN; MANUFACTURER_PART_NUMBER FDMC8622; DIGIKEY_PART_NUMBER FDMC8622CT-ND
Q3: BC857W; SOT-323_SC-70; MANUFACTURER_PART_NUMBER BC857W,135; DIGIKEY_PART_NUMBER 1727-BC857W,135CT-ND
R2: 1.2M; R_1206_3216Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-8ENF1204V; DIGIKEY_PART_NUMBER P1.20MFCT-ND
R3: 39.2k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF3922X; DIGIKEY_PART_NUMBER P39.2KLCT-ND
R4: 174k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF1743X; DIGIKEY_PART_NUMBER P174KLCT-ND
R5, R8, R19, R21, R29: 100k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF1003X; DIGIKEY_PART_NUMBER P100KLCT-ND
R6: 2M; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-U02F2004X; DIGIKEY_PART_NUMBER 10-ERJ-U02F2004XCT-ND
R7: 1k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF1001X; DIGIKEY_PART_NUMBER P1.00KLCT-ND
R9, R10, R11, R12: 1.5M; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2GEJ155X; DIGIKEY_PART_NUMBER P1.5MJCT-ND
R13: 232; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF2320X; DIGIKEY_PART_NUMBER P232LCT-ND
R14: 909; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF9090X; DIGIKEY_PART_NUMBER P909LCT-ND
R15: 26.1k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF2612X; DIGIKEY_PART_NUMBER P26.1KLCT-ND
R16: 25m; R_1206_3216Metric; TOLERANCE 0.5%; MANUFACTURER_PART_NUMBER MCS1632R025DER; DIGIKEY_PART_NUMBER 273-MCS1632R025DERCT-ND
R17, R22, R23, R24, R26, R27, R28: 10k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF1002X; DIGIKEY_PART_NUMBER P10.0KLCT-ND
R18: 24.9k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF2492X; DIGIKEY_PART_NUMBER P24.9KLCT-ND
R20: 10k; R_1210_3225Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-14NF1002U; DIGIKEY_PART_NUMBER P10.0KAACT-ND
R25: 180k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF1803X; DIGIKEY_PART_NUMBER P180KLCT-ND
R30: 25m; R_1206_3216Metric; TOLERANCE 0.5%; MANUFACTURER_PART_NUMBER WSL1206R0250FEA; DIGIKEY_PART_NUMBER WSLC-.025CT-ND
U2: LMV393; MANUFACTURER_PART_NUMBER LMV393IDGKR; DIGIKEY_PART_NUMBER 296-13993-1-ND
U3, U4, U5, U6: BC846BPDW1T1G; SOT-363_SC-70-6; PARTREV 12; DIGIKEY_PART_NUMBER BC846BPDW1T1GOSTR-ND
U7, U8: FDMQ8205A; IC_FDMQ8205A; PARTREV 1.0; DIGIKEY_PART_NUMBER FDMQ8205AOSTR-ND
U9: NCP1095DBR2; TSSOP-16_948F-01_OSI; MANUFACTURER_PART_NUMBER NCP1095DBR2; DIGIKEY_PART_NUMBER NCP1095DBR2OSTR-ND
U10: INA228AQDGSRQ1; VSSOP10_DGS_TEX; MANUFACTURER_PART_NUMBER INA228AQDGSRQ1; DIGIKEY_PART_NUMBER 296-INA228AQDGSRQ1CT-ND

Connections:
3V3: C12.1, R4.2, R8.2, R23.2, R26.2, U10.6 (VS); also elsewhere on the board
5V: C5.1, U2.6 (-), U2.8 (V+); also elsewhere on the board
GBR: D1.3 (K), U9.11 (GBR)
GND: C3.2, C4.2, C5.2, C8.2, C10.2, C12.2, Q1.2 (E), Q2.5, Q2.6, Q2.7, Q2.8 (D), Q4.2 (E), Q5.2 (E), R3.1, R5.1, R19.1, U2.4 (V-), U2.5 (+), U9.12 (RTN), U10.1 (A1), U10.2 (A0), U10.7 (GND); also elsewhere on the board
I2C_SCL: U10.5 (SCL); also elsewhere on the board
I2C_SDA: U10.4 (SDA); also elsewhere on the board
INA_ALERT_V_POE: U10.3 (ALERT); also elsewhere on the board
KILL_N: Q1.3 (C), Q5.3 (C), R21.1, R22.2
unnamed: D1.1 (A_1), D2.2, D2.5
unnamed: D1.2 (A_2), D3.2, D3.5
unnamed: D2.1, R9.2
unnamed: D2.4, R10.2
unnamed: D3.1, R11.1
unnamed: D3.4, R12.1
unnamed: C7.2, D4.1 (K), Q3.2 (E), R18.1, R21.2
unnamed: Q1.1 (B), R17.2, R19.2
unnamed: Q2.4 (G), U9.10 (PGATE)
unnamed: Q2.1 (S), Q2.2, Q2.3, R16.2, U9.9 (PSNS)
unnamed: Q3.1 (B), R22.1
unnamed: C9.2, Q3.3 (C), R25.1, R27.1
unnamed: Q4.1 (B), R24.2
unnamed: Q4.3 (C), R26.1, R28.1
unnamed: Q5.1 (B), R28.2
unnamed: R6.2, R7.1, U2.1
unnamed: R9.1, U3.2, U3.3, U3.5
unnamed: R10.1, U4.2, U4.3, U4.5
unnamed: R11.2, U5.2, U5.3, U5.5
unnamed: R12.2, U6.2, U6.3, U6.5
unnamed: C3.1, R2.1, R3.2, R6.1, U2.3 (+)
unnamed: C4.1, R4.1, R5.2, U2.2 (-)
unnamed: U4.6, U7.4 (G2)
unnamed: U3.6, U7.9 (G3)
unnamed: U6.6, U8.4 (G2)
unnamed: U5.6, U8.9 (G3)
unnamed: R13.1, U9.2 (CLA)
unnamed: R14.1, U9.3 (CLB)
unnamed: C6.2, R15.1, U9.5 (COSC)
unnamed: R15.2, U9.7 (DET)
PFI: R7.2, R8.1; also elsewhere on the board
POE_KILL: R17.1; also elsewhere on the board
POE_LCF: U9.13 (LCF); also elsewhere on the board
POE_NCL: U9.16 (NCL); also elsewhere on the board
POE_NCM: U9.15 (NCM); also elsewhere on the board
POE_PG: R20.2, U9.14 (PGO); also elsewhere on the board
TR0_TAP: U3.1, U3.4, U7.12 (G4), U7.13 (INPUT1), U7.14 (INPUT1__1); also elsewhere on the board
TR1_TAP: U4.1, U4.4, U7.1 (G1), U7.15 (INPUT2), U7.16 (INPUT2__1); also elsewhere on the board
TR2_TAP: U5.1, U5.4, U8.12 (G4), U8.13 (INPUT1), U8.14 (INPUT1__1); also elsewhere on the board
TR3_TAP: U6.1, U6.4, U8.1 (G1), U8.15 (INPUT2), U8.16 (INPUT2__1); also elsewhere on the board
VAUX: C11.2, R27.2, R29.1, U9.4 (AUX)
VOUT_N: C6.1, C7.1, C9.1, C11.1, CR1.2, D4.2 (A), R13.2, R14.2, R16.1, R25.2, R29.2, U7.2 (OUTN), U7.3 (OUTN__1), U7.10 (OUTN__2), U7.11 (OUTN__3), U8.2 (OUTN), U8.3 (OUTN__1), U8.10 (OUTN__2), U8.11 (OUTN__3), U9.6 (ACS), U9.8 (VPN)
VOUT_P: C8.1, C10.1, CR1.1, R18.2, R20.1, R30.1, U7.5 (OUTP), U7.6 (OUTP__1), U7.7 (OUTP__2), U7.8 (OUTP__3), U8.5 (OUTP), U8.6 (OUTP__1), U8.7 (OUTP__2), U8.8 (OUTP__3), U9.1 (VPP), U10.10 (IN+)
V_POE: R2.2, R30.2, U10.8 (VBUS), U10.9 (IN-); also elsewhere on the board
WDO_N: R23.1, R24.1; also elsewhere on the board

Notes on the sheet:
4.65A on VOUT_P ->
500 mA for each tap (TR0, TR1, TR2, TR3)
I2C Address: 0x40
Configured for PD Power Class 6 25W, PoE++ Type 3

Schematic: gps-antenna.kicad_sch

Parts:
C52, C57: 1uF; C_0603_1608Metric; TOLERANCE 10%; VOLTAGE 16V; MANUFACTURER_PART_NUMBER C0603C105K4RACAUTO; DIGIKEY_PART_NUMBER 399-17704-1-ND
C53, C54, C55, C56, C58, C60, C61: 0.1uF; C_0402_1005Metric; TOLERANCE 10%; VOLTAGE 16V; MANUFACTURER_PART_NUMBER GCM155R71C104KA55D; DIGIKEY_PART_NUMBER 490-4759-1-ND
C59: 10uF; C_1206_3216Metric; TOLERANCE 10%; VOLTAGE 16V; MANUFACTURER_PART_NUMBER CL31B106KOHVPNE; DIGIKEY_PART_NUMBER 1276-6797-1-ND
C62: 1nF; C_0402_1005Metric; TOLERANCE 5%; VOLTAGE 50V; MANUFACTURER_PART_NUMBER C0402C102J5GECAUTO; DIGIKEY_PART_NUMBER 399-C0402C102J5GECAUTOCT-ND
FB4: 120; 402; MANUFACTURER_PART_NUMBER BLM15HD121SN1D; DIGIKEY_PART_NUMBER 490-15018-1-ND
FB5, FB6: 600; 1206; MANUFACTURER_PART_NUMBER BLM31PG601SN1L; DIGIKEY_PART_NUMBER 490-16533-1-ND
L1: 47nH; L_0402_1005Metric; MANUFACTURER_PART_NUMBER LQG15HS47NJ02D; DIGIKEY_PART_NUMBER 490-2631-1-ND
Q11: NSS40300MZ4T1G; SOT-223; MANUFACTURER_PART_NUMBER NSS40300MZ4T1G; DIGIKEY_PART_NUMBER NSS40300MZ4T1GOSCT-ND
Q12, Q13: BC857W; SOT-323_SC-70; MANUFACTURER_PART_NUMBER BC857W,135; DIGIKEY_PART_NUMBER 1727-BC857W,135CT-ND
Q14: BC847W; SOT-323_SC-70; MANUFACTURER_PART_NUMBER BC847W,135; DIGIKEY_PART_NUMBER 1727-BC847W,135CT-ND
R73: 2.2k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF2201X; DIGIKEY_PART_NUMBER P2.20KLCT-ND
R74, R79, R84, R87, R88, R200: 10k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF1002X; DIGIKEY_PART_NUMBER P10.0KLCT-ND
R75: 4.7k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF4701X; DIGIKEY_PART_NUMBER P4.70KLCT-ND
R76: 220; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF2200X; DIGIKEY_PART_NUMBER P220LCT-ND
R77: 3.3; R_1206_3216Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER RMCF1206FT3R30; DIGIKEY_PART_NUMBER 738-RMCF1206FT3R30CT-ND
R78, R80, R81, R82, R85: 100k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF1003X; DIGIKEY_PART_NUMBER P100KLCT-ND
R83: 30k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER RK73H1ETTP3002F; DIGIKEY_PART_NUMBER 2019-RK73H1ETTP3002FCT-ND
R86: 11k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF1102X; DIGIKEY_PART_NUMBER P11.0KLCT-ND
R89: 150m; R_1206_3216Metric; TOLERANCE 0.5%; MANUFACTURER_PART_NUMBER WSL1206R1500FEA; DIGIKEY_PART_NUMBER WSLC-.15CT-ND
U24: INA181A1IDBVR; SOT-23-6; MANUFACTURER_PART_NUMBER INA181A1IDBVR; DIGIKEY_PART_NUMBER 296-47656-1-ND
U25: LMV393; MANUFACTURER_PART_NUMBER LMV393IDGKR; DIGIKEY_PART_NUMBER 296-13993-1-ND
U26: INA228AQDGSRQ1; VSSOP10_DGS_TEX; MANUFACTURER_PART_NUMBER INA228AQDGSRQ1; DIGIKEY_PART_NUMBER 296-INA228AQDGSRQ1CT-ND
U27: RT9742VGJ5; TSOT-23-5; MANUFACTURER_PART_NUMBER RT9742VGJ5; DIGIKEY_PART_NUMBER 1028-RT9742VGJ5TR-ND

Connections:
3V3: C60.1, U26.1 (A1), U26.2 (A0), U26.6 (VS); also elsewhere on the board
3V3_GPS: C54.1, C55.1, C56.1, R82.1, R84.2, R85.1, R87.2, U24.6 (V+); also elsewhere on the board
3V3_STM: R200.1; also elsewhere on the board
5V: FB5.2, U27.5 (IN); also elsewhere on the board
ANT_BIAS_EN: R88.1, U27.4 (EN); also elsewhere on the board
GND: C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, Q14.2 (E), R73.2, R78.1, R81.1, R83.1, R86.1, R88.2, U24.2 (GND), U24.5 (REF), U25.4 (V-), U26.7 (GND), U27.2 (GND); also elsewhere on the board
GPS_ANT_DETECT: R87.1, U25.1; also elsewhere on the board
GPS_ANT_OFF_MON: R79.1; also elsewhere on the board
GPS_ANT_SHORT: R84.1, U25.7; also elsewhere on the board
GPS_RF_IN: L1.1; also elsewhere on the board
I2C_SCL: U26.5 (SCL); also elsewhere on the board
I2C_SDA: U26.4 (SDA); also elsewhere on the board
INA_ALERT_V_ANT: U26.3 (ALERT); also elsewhere on the board
unnamed: Q11.1 (B), Q12.3 (C), Q13.3 (C), R73.1
unnamed: C52.1, L1.2, Q11.2 (C), R80.1
unnamed: Q11.3 (E), Q12.1 (B), R77.1, U24.4 (IN-)
unnamed: Q12.2 (E), R76.1
unnamed: Q13.1 (B), R74.1, R75.2
unnamed: Q14.1 (B), R78.2, R79.2
unnamed: Q14.3 (C), R75.1
unnamed: C53.1, FB4.1, R76.2, R77.2, U24.3 (IN+)
unnamed: U24.1 (OUT), U25.3 (+)
unnamed: R85.2, R86.2, U25.2 (-)
unnamed: R80.2, R81.2, U25.5 (+)
unnamed: R82.2, R83.2, U25.6 (-)
unnamed: C57.1, C58.1, FB5.1, U25.8 (V+)
unnamed: C59.1, R89.1, U26.10 (IN+), U27.1 (OUT)
unnamed: FB6.2, R89.2, U26.8 (VBUS), U26.9 (IN-)
V_ANT: C61.1, C62.1, FB4.2, FB6.1, Q13.2 (E), R74.2
V_ANT_EN_FAULT: R200.2, U27.3 (nFLG); also elsewhere on the board

Notes on the sheet:
I2C Address: 0x45
5V, 150mA max
Design State =================== State: In Progress Documented: 6/3/26 Reviewed: 6/3/2026 BOM Updated:

Schematic: refclock-input.kicad_sch

Parts:
C149, C150, C153, C183, C184: 0.1uF; C_0402_1005Metric; TOLERANCE 10%; VOLTAGE 16V; MANUFACTURER_PART_NUMBER GCM155R71C104KA55D; DIGIKEY_PART_NUMBER 490-4759-1-ND
C151, C155: 10nF; C_0402_1005Metric; TOLERANCE 10%; VOLTAGE 16V; MANUFACTURER_PART_NUMBER GRT155R71C103KE01J; DIGIKEY_PART_NUMBER 490-GRT155R71C103KE01JCT-ND
C152: 1uF; C_0603_1608Metric; TOLERANCE 10%; VOLTAGE 16V; MANUFACTURER_PART_NUMBER C0603C105K4RACAUTO; DIGIKEY_PART_NUMBER 399-17704-1-ND
C154, C156: 10uF; C_1206_3216Metric; TOLERANCE 10%; VOLTAGE 16V; MANUFACTURER_PART_NUMBER CL31B106KOHVPNE; DIGIKEY_PART_NUMBER 1276-6797-1-ND
D18, D19: BAT54S; SOT-23-3; MANUFACTURER_PART_NUMBER BAT54S; DIGIKEY_PART_NUMBER 4878-BAT54SCT-ND
D20, D21: 3V3; SOT-23-3; MANUFACTURER_PART_NUMBER BZX84C3V3LT1G; DIGIKEY_PART_NUMBER BZX84C3V3LT1GOSCT-ND
FB9: 600; 1206; MANUFACTURER_PART_NUMBER BLM31PG601SN1L; DIGIKEY_PART_NUMBER 490-16533-1-ND
R174, R175: 47k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF4702X; DIGIKEY_PART_NUMBER P47.0KLCT-ND
R176, R182: 100k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF1003X; DIGIKEY_PART_NUMBER P100KLCT-ND
R177: 49.9; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF49R9X; DIGIKEY_PART_NUMBER P49.9LCT-ND
R178: 100; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF1000X; DIGIKEY_PART_NUMBER P100LCT-ND
R179, R180, R266: 10k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF1002X; DIGIKEY_PART_NUMBER P10.0KLCT-ND
R181: 1k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF1001X; DIGIKEY_PART_NUMBER P1.00KLCT-ND
R183, R184: 33; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF33R0X; DIGIKEY_PART_NUMBER P33.0LCT-ND
R185: 1.5k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF1501X; DIGIKEY_PART_NUMBER P1.50KLCT-ND
R186: 30.1k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF3012X; DIGIKEY_PART_NUMBER P30.1KLCT-ND
R218: 49.9k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF4992X; DIGIKEY_PART_NUMBER P49.9KLCT-ND
R219: 402k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF4023X; DIGIKEY_PART_NUMBER P402KLCT-ND
U49: TMUX1101DCK; SOT-353_SC-70-5; MANUFACTURER_PART_NUMBER TMUX1101DCK; DIGIKEY_PART_NUMBER 296-TMUX1101DCKRCT-ND
U50: LTC6752xS5; TSOT-23-5; MANUFACTURER_PART_NUMBER LTC6752IS5#TRMPBF; DIGIKEY_PART_NUMBER 505-LTC6752IS5#TRMPBFCT-ND
U51: LT3045xDD; DFN-10-1EP_3x3mm_P0.5mm_EP1.65x2.38mm; MANUFACTURER_PART_NUMBER LT3045EDD#TRPBF; DIGIKEY_PART_NUMBER 505-LT3045EDD#TRPBFCT-ND

Connections:
3V0_RF: C156.1, C184.1, D18.2 (K), D19.2 (K), D20.1 (K), R174.2, R179.2, R183.2, R219.1, U49.5 (V_{DD}), U51.9 (OUTS), U51.10 (OUT)
3V0_RF_LDO_PG: R266.2, U51.4 (PG); also elsewhere on the board
3V3: R176.2; also elsewhere on the board
3V3_STM: R266.1; also elsewhere on the board
5V: FB9.2; also elsewhere on the board
5V_PSU_PG: U51.3 (EN/UV); also elsewhere on the board
10MHz_CLK_OUT: R184.1; also elsewhere on the board
10MHz_RF_IN: C149.1; also elsewhere on the board
GND: C152.2, C153.2, C154.2, C155.2, C156.2, C183.2, C184.2, D18.1 (A), D19.1 (A), D20.2 (A), D21.2 (A), R175.1, R180.1, R185.2, R186.2, R218.2, U49.1, U49.3 (GND), U50.2 (VEE), U51.8 (GND), U51.11 (GND); also elsewhere on the board
unnamed: C149.2, R174.1, R175.2, R177.2, R178.2
unnamed: C150.1, R177.1
unnamed: C151.2, R181.2
unnamed: C154.1, FB9.1, U51.1 (IN), U51.2 (IN)
unnamed: C150.2, D18.3 (COM), U49.2
unnamed: C151.1, D19.3 (COM), R178.1
unnamed: C152.1, C153.1, D21.1 (K), R183.1, U50.5 (VCC)
unnamed: R184.2, U50.1
unnamed: R181.1, R182.2, U50.3 (+)
unnamed: C183.1, R179.1, R180.2, R182.1, U50.4 (-)
unnamed: R185.1, U51.5 (ILIM)
unnamed: R218.1, R219.2, U51.6 (PGFB)
unnamed: C155.1, R186.1, U51.7 (SET)
REF_TERM_EN: R176.1, U49.4; also elsewhere on the board

Notes on the sheet:
50-ohm trace
50-ohm trace all the way through this circuit
Noise Sensitive See Datasheet for Layout

Schematic: i2c-peripherals.kicad_sch

Parts:
C171, C172, C173, C174, C175, C177, C178, C205: 0.1uF; C_0402_1005Metric; TOLERANCE 10%; VOLTAGE 16V; MANUFACTURER_PART_NUMBER GCM155R71C104KA55D; DIGIKEY_PART_NUMBER 490-4759-1-ND
C176: 220nF; C_0402_1005Metric; TOLERANCE 10%; VOLTAGE 16V; MANUFACTURER_PART_NUMBER GCM155R71C224KE02J; DIGIKEY_PART_NUMBER 490-GCM155R71C224KE02JCT-ND
U57, U58: TMP117xxDRV; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm; MANUFACTURER_PART_NUMBER TMP117AIDRVR; DIGIKEY_PART_NUMBER 296-51834-1-ND
U59: LIS2DH12TR; LGA-12_STM; MANUFACTURER_PART_NUMBER LIS2DH12TR; DIGIKEY_PART_NUMBER 497-14851-1-ND
U60: ATECC608B-SSHDA; SOIC-8_3.9x4.9mm_P1.27mm; MANUFACTURER_PART_NUMBER ATECC608B-SSHDA; DIGIKEY_PART_NUMBER 150-ATECC608B-SSHDA-TCT-ND
U61: IIS2MDCTR; LGA-12_2X2X0P7_STM; MANUFACTURER_PART_NUMBER IIS2MDCTR; DIGIKEY_PART_NUMBER 497-17728-1-ND
U72: SHT45-AD1B-R2; Sensirion_DFN-4_1.5x1.5mm_P0.8mm_SHT4x_NoCentralPad; MANUFACTURER_PART_NUMBER SHT45-AD1B-R2; DIGIKEY_PART_NUMBER 1649-SHT45-AD1B-R2CT-ND

Connections:
3V3_STM: C171.1, C172.1, C173.1, C174.1, C175.1, C177.1, C178.1, C205.1, U57.4 (ADD0), U57.5 (V+), U58.5 (V+), U59.2 (CS), U59.3 (SDO/SA0), U59.9 (VDD), U59.10 (VDD_IO), U60.8 (VCC), U61.3 (CS), U61.9 (VDD), U61.10 (VDD_IO), U72.3 (VDD); also elsewhere on the board
GND: C171.2, C172.2, C173.2, C174.2, C175.2, C176.2, C177.2, C178.2, C205.2, U57.2 (GND), U58.2 (GND), U58.4 (ADD0), U59.5 (RES), U59.6 (GND), U59.7 (GND), U59.8 (GND), U60.4 (GND), U61.6 (GND), U61.8 (GND), U72.4 (VSS); also elsewhere on the board
I2C_SCL: U57.1 (SCL), U58.1 (SCL), U59.1 (SCL/SPC), U60.6 (SCL), U61.1 (SCL/SPC), U72.2 (SCL); also elsewhere on the board
I2C_SDA: U57.6 (SDA), U58.6 (SDA), U59.4 (SDA/SDI/SDO), U60.5 (SDA), U61.4 (SDA/SDI/SDO), U72.1 (SDA); also elsewhere on the board
unnamed: C176.1, U61.5 (C1)

Notes on the sheet:
Place on opposite side of PCB from OCXO and connect ground fill between layers to pass temp to this device from OCXO
Keep higer power traces 5mm+ away Do not route traces under on any layer Keep away from magnetics Keep away from power supplies
I2C Address: 0x48
Place with same orrientation on PCB
I2C Address: 0x19
I2C Address: 0x1E
I2C Address: 0x49
I2C Address: 0x44
Place far away from everything but next to each other

Schematic: connectors.kicad_sch

Parts:
C40: 1uF; C_0603_1608Metric; TOLERANCE 10%; VOLTAGE 16V; MANUFACTURER_PART_NUMBER C0603C105K4RACAUTO; DIGIKEY_PART_NUMBER 399-17704-1-ND
C41, C43, C188: 0.1uF; C_0402_1005Metric; TOLERANCE 10%; VOLTAGE 16V; MANUFACTURER_PART_NUMBER GCM155R71C104KA55D; DIGIKEY_PART_NUMBER 490-4759-1-ND
C42, C186: 4.7nF; C_1812_4532Metric; TOLERANCE 10%; VOLTAGE 2kV; MANUFACTURER_PART_NUMBER C1812C472KGRACAUTO; DIGIKEY_PART_NUMBER 399-16791-1-ND
D6: SMF5V0A; D_SMF; MANUFACTURER_PART_NUMBER SMF5V0A-HE3_A08; DIGIKEY_PART_NUMBER 112-SMF5V0A-HE3_A08CT-ND
D7: 1.5SMCJ28A; D_SMC; MANUFACTURER_PART_NUMBER 1.5SMCJ28A; DIGIKEY_PART_NUMBER 4878-1.5SMCJ28ACT-ND
D8, D9, D23: SZESD7410MXWT5G; 2-XDFN; MANUFACTURER_PART_NUMBER SZESD7410MXWT5G; DIGIKEY_PART_NUMBER 488-SZESD7410MXWT5GCT-ND
D22: SMF5V0A; DO-219AB (SMF); MANUFACTURER_PART_NUMBER SMF5V0A-HE3_A08; DIGIKEY_PART_NUMBER 112-SMF5V0A-HE3_A08CT-ND
D26: SMAJ15CA; DO-214AC; MANUFACTURER_PART_NUMBER SMAJ15CA; DIGIKEY_PART_NUMBER 732-SMAJ15CATR-ND
J2: OSTVN04A150; CONN_OSTVN04A150_OST; MANUFACTURER_PART_NUMBER OSTVN04A150; DIGIKEY_PART_NUMBER ED10563-ND
J3: BG055-06A-1-0450-0530-0350-L-D; GCT_BG055-06A-1-0450-0530-0350-L-D; MANUFACTURER_PART_NUMBER BG055-06A-1-0450-0530-0350-L-D; DIGIKEY_PART_NUMBER 2073-BG055-06A-1-0450-0530-0350-L-D-ND
J5: USB4120-03-C; GCT_USB4120-03-C_REVA6; MANUFACTURER_PART_NUMBER USB4120-03-C; DIGIKEY_PART_NUMBER 2073-USB4120-03-CCT-ND
J6: 622-009-260-033; DB9_Socket; MANUFACTURER_PART_NUMBER 622-009-260-033; DIGIKEY_PART_NUMBER 151-622-009-260-033-ND
J7, J8, J9, J15: SMA-J-P-H-RA-TH1; SAMTEC_SMA-J-P-X-RA-TH1; MANUFACTURER_PART_NUMBER SMA-J-P-H-RA-TH1; DIGIKEY_PART_NUMBER SAM8856-ND
J10: OSTVN02A150; CONN_OSTVN02A150_OST; MANUFACTURER_PART_NUMBER OSTVN02A150; DIGIKEY_PART_NUMBER ED10561-ND
J16: OSTVN06A150; CONN_OSTVN06A150_OST; MANUFACTURER_PART_NUMBER OSTVN06A150; DIGIKEY_PART_NUMBER ED10565-ND
J17: 1787179; PHOENIX_1787179; MANUFACTURER_PART_NUMBER 1787179; DIGIKEY_PART_NUMBER 277-8750-ND
L10: PGB1010603MR; L_0603_1608Metric; MANUFACTURER_PART_NUMBER PGB1010603MR; DIGIKEY_PART_NUMBER F2594CT-ND
R64, R66: 5.1k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF5101X; DIGIKEY_PART_NUMBER P5.10KLCT-ND
R65, R231: 1M; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF1004X; DIGIKEY_PART_NUMBER P1.00MLCT-ND
R67: 121k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF1213X; DIGIKEY_PART_NUMBER P121KLCT-ND
R68: 100k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF1003X; DIGIKEY_PART_NUMBER P100KLCT-ND
U15, U16, U19, U20: TPD4E02B04DQAR; MANUFACTURER_PART_NUMBER TPD4E02B04DQAR; DIGIKEY_PART_NUMBER 296-43875-1-ND
U17, U18: TPD4E05U06DQAR; TPD4E02B04DQAR; MANUFACTURER_PART_NUMBER TPD4E05U06DQAR; DIGIKEY_PART_NUMBER 296-35765-1-ND
U65, U66, U69, U70: TPD4E05U06DQAR; USON-10_2.5x1.0mm_P0.5mm; MANUFACTURER_PART_NUMBER TPD4E05U06DQAR; DIGIKEY_PART_NUMBER 296-35765-1-ND

Connections:
1PPS_OUT: D23.1, J15.1 (In); also elsewhere on the board
3V3_STM: J3.1; also elsewhere on the board
5V: C188.1, D22.1 (A1), J2.1, J17.28; also elsewhere on the board
5V_DISP: C40.1, C41.1, D6.1 (A1), J17.16; also elsewhere on the board
10MHz_RF_IN: D8.1, J8.1 (In); also elsewhere on the board
10MHz_RF_OUT: D9.1, J9.1 (In); also elsewhere on the board
BUTTON_1: J17.1, U19.1 (D1+), U19.10 (NC); also elsewhere on the board
BUTTON_2: J17.19, U19.2 (D1-), U19.9 (NC); also elsewhere on the board
BUTTON_3: J17.2, U19.4 (D2+), U19.7 (NC); also elsewhere on the board
BUTTON_4: J17.20, U19.5 (D2-), U19.6 (NC); also elsewhere on the board
BUTTON_5: J17.21, U20.1 (D1+), U20.10 (NC); also elsewhere on the board
BUTTON_6: J17.4, U20.2 (D1-), U20.9 (NC); also elsewhere on the board
BUTTON_7: J17.22, U20.4 (D2+), U20.7 (NC); also elsewhere on the board
DISP_BL: J17.14, U15.5 (D2-), U15.6 (NC); also elsewhere on the board
DISP_CS: J17.12, U15.1 (D1+), U15.10 (NC); also elsewhere on the board
DISP_DC: J17.31, U15.4 (D2+), U15.7 (NC); also elsewhere on the board
DISP_RST: J17.30, U15.2 (D1-), U15.9 (NC); also elsewhere on the board
DISP_TOUCH_INT: J17.33, U17.4 (D2+), U17.7 (NC); also elsewhere on the board
ENC_A_IN: J17.11, U69.4 (D2+), U69.7 (NC); also elsewhere on the board
ENC_BUTTON: J17.9, U69.1 (D1+), U69.10 (NC); also elsewhere on the board
ENC_B_IN: J17.27, U69.2 (D1-), U69.9 (NC); also elsewhere on the board
FAN_PWM: J2.2; also elsewhere on the board
FAN_TACH: J2.4; also elsewhere on the board
GND: C40.2, C41.2, C42.2, C43.2, C186.2, C188.2, D6.2 (A2), D7.2 (A2), D8.2, D9.2, D22.2 (A2), D23.2, D26.1 (A1), J2.3, J3.3, J5.A1 (GND_A), J5.A12 (GND_A__1), J5.B1 (GND_B), J5.B12 (GND_B__1), J6.2, J6.5, J7.2 (Ext), J8.2 (Ext), J9.2 (Ext), J10.2, J15.2 (Ext), J17.3, J17.10, J17.13, J17.35, J17.36, L10.2, R64.2, R65.2, R66.2, R67.2, R231.2, U15.3 (GND), U15.8 (GND), U16.3 (GND), U16.8 (GND), U17.3 (GND), U17.8 (GND), U18.3 (GND), U18.8 (GND), U19.3 (GND), U19.8 (GND), U20.3 (GND), U20.8 (GND), U65.3 (GND), U65.8 (GND), U66.3 (GND), U66.8 (GND), U69.3 (GND), U69.8 (GND), U70.3 (GND), U70.8 (GND); also elsewhere on the board
GPS_RF_IN: J7.1 (In), L10.1; also elsewhere on the board
HOLDOVER_ALARM_C1: J16.2; also elsewhere on the board
HOLDOVER_ALARM_C2: J16.5; also elsewhere on the board
HOLDOVER_ALARM_NC1: J16.3; also elsewhere on the board
HOLDOVER_ALARM_NC2: J16.6; also elsewhere on the board
HOLDOVER_ALARM_NO1: J16.1; also elsewhere on the board
HOLDOVER_ALARM_NO2: J16.4; also elsewhere on the board
I2C_DISP_SCL: J17.32, U17.1 (D1+), U17.10 (NC); also elsewhere on the board
I2C_DISP_SDA: J17.15, U17.2 (D1-), U17.9 (NC); also elsewhere on the board
MCU_NRST: J3.5; also elsewhere on the board
unnamed: C42.1, J5.S1 (SHIELD), J5.S2 (SHIELD__1), J5.S3 (SHIELD__2), J5.S4 (SHIELD__3), R65.1
unnamed: C186.1, J6.SH (PAD), R231.1
PANEL_LEDS_P: J17.26, U70.5 (D2-), U70.6 (NC); also elsewhere on the board
PANEL_LED_RED_N_1: J17.8, U70.4 (D2+), U70.7 (NC); also elsewhere on the board
PANEL_LED_WHITE_N_1: J17.5, U66.1 (D1+), U66.10 (NC); also elsewhere on the board
PANEL_LED_WHITE_N_2: J17.23, U66.2 (D1-), U66.9 (NC); also elsewhere on the board
PANEL_LED_WHITE_N_3: J17.6, U66.4 (D2+), U66.7 (NC); also elsewhere on the board
PANEL_LED_WHITE_N_4: J17.24, U66.5 (D2-), U66.6 (NC); also elsewhere on the board
PANEL_LED_WHITE_N_5: J17.7, U70.1 (D1+), U70.10 (NC); also elsewhere on the board
PANEL_LED_WHITE_N_6: J17.25, U70.2 (D1-), U70.9 (NC); also elsewhere on the board
PROX_WAKE: J17.18, U16.4 (D2+), U16.7 (NC); also elsewhere on the board
RB_LOCK_IN: D26.2 (A2), J6.3; also elsewhere on the board
RB_RS232_RX: J6.9; also elsewhere on the board
RB_RS232_TX: J6.8; also elsewhere on the board
RTC_TAMPER: J10.1, U16.5 (D2-), U16.6 (NC); also elsewhere on the board
SPI_MOSI_DISP: J17.34, U16.1 (D1+), U16.10 (NC); also elsewhere on the board
SPI_SCK_DISP: J17.17, U16.2 (D1-), U16.9 (NC); also elsewhere on the board
SWCLK: J3.2; also elsewhere on the board
SWDIO: J3.4; also elsewhere on the board
SWO: J3.6; also elsewhere on the board
USB_CC1: J5.A5 (CC1), R66.1, U65.1 (D1+), U65.10 (NC)
USB_CC2: J5.B5 (CC2), R64.1, U65.2 (D1-), U65.9 (NC)
USB_D+: J5.A6 (D1+), J5.B6 (D2+), U18.1 (D1+), U18.10 (NC); also elsewhere on the board
USB_D-: J5.A7 (D1-), J5.B7 (D2-), U18.2 (D1-), U18.9 (NC); also elsewhere on the board
USB_VBUS: J5.A4 (VBUS_A), J5.A9 (VBUS_A__1), J5.B4 (VBUS_B), J5.B9 (VBUS_B__1), R68.2, U18.4 (D2+), U18.7 (NC)
USB_VBUS_SENSE: C43.1, R67.1, R68.1; also elsewhere on the board
VCC_RB_G: D7.1 (A1), J6.1; also elsewhere on the board

Notes on the sheet:
50-ohm trace
TOP
STM32 Program/Debug Port
27W Peak
Place ALL Components on this sheet CLOSE to their connectors
USB DP and DM 90 ohm traces equal length
BOTTOM

Schematic: stm32.kicad_sch

Parts:
C21, C22, C23, C24, C25, C26, C35, C194, C195, C196, C197, C198, C199: 0.1uF; C_0402_1005Metric; TOLERANCE 10%; VOLTAGE 16V; MANUFACTURER_PART_NUMBER GCM155R71C104KA55D; DIGIKEY_PART_NUMBER 490-4759-1-ND
C27, C30, C33: 4.7uF; C_0805_2012Metric; TOLERANCE 10%; VOLTAGE 16V; MANUFACTURER_PART_NUMBER GRT21BR71C475KE13K; DIGIKEY_PART_NUMBER 490-GRT21BR71C475KE13KCT-ND
C28: 1uF; C_0603_1608Metric; TOLERANCE 10%; VOLTAGE 16V; MANUFACTURER_PART_NUMBER C0603C105K4RACAUTO; DIGIKEY_PART_NUMBER 399-17704-1-ND
C29, C31: 12pF; C_0402_1005Metric; TOLERANCE 5%; VOLTAGE 50V; MANUFACTURER_PART_NUMBER GCM1555C1H120FA16D; DIGIKEY_PART_NUMBER 490-16460-1-ND
C32: 10uF; C_1206_3216Metric; TOLERANCE 10%; VOLTAGE 16V; MANUFACTURER_PART_NUMBER CL31B106KOHVPNE; DIGIKEY_PART_NUMBER 1276-6797-1-ND
C34, C36, C38, C39: 2.2uF; C_0805_2012Metric; TOLERANCE 10%; VOLTAGE 16V; MANUFACTURER_PART_NUMBER GRT21BR71C225KE01L; DIGIKEY_PART_NUMBER 490-GRT21BR71C225KE01LCT-ND
C37: 0.1uF; C_1210_3225Metric; TOLERANCE 5%; VOLTAGE 50V; MANUFACTURER_PART_NUMBER C1210C104J5GACAUTO; DIGIKEY_PART_NUMBER 399-15804-1-ND
FB2: 600; 1206; MANUFACTURER_PART_NUMBER BLM31PG601SN1L; DIGIKEY_PART_NUMBER 490-16533-1-ND
Q6, Q7: BC847W; SOT-323_SC-70; MANUFACTURER_PART_NUMBER BC847W,135; DIGIKEY_PART_NUMBER 1727-BC847W,135CT-ND
R46: 1.5k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF1501X; DIGIKEY_PART_NUMBER P1.50KLCT-ND
R47: 33.2k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF3322X; DIGIKEY_PART_NUMBER P33.2KLCT-ND
R48: 50; R_0603_1608Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER CRCW060350R0FKEA; DIGIKEY_PART_NUMBER 541-3318-1-ND
R50, R51, R52, R53, R54, R233, R263: 10k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF1002X; DIGIKEY_PART_NUMBER P10.0KLCT-ND
R232: 1.21k; R_0402_1005Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-2RKF1211X; DIGIKEY_PART_NUMBER P1.21KLCT-ND
R264: 162k; R_1206_3216Metric; TOLERANCE 1%; MANUFACTURER_PART_NUMBER ERJ-8ENF1623V; DIGIKEY_PART_NUMBER P162KFCT-ND
U12: STM32H563ZIT6; QFP50P2200X2200X160-144N; MANUFACTURER_PART_NUMBER STM32H563ZIT6; DIGIKEY_PART_NUMBER 497-STM32H563ZIT6-ND
U13: LT3045xDD; DFN-10-1EP_3x3mm_P0.5mm_EP1.65x2.38mm; MANUFACTURER_PART_NUMBER LT3045EDD#TRPBF; DIGIKEY_PART_NUMBER 505-LT3045EDD#TRPBFCT-ND
U14: MCP1502T-33E/CHY; SOT-23-6; MANUFACTURER_PART_NUMBER MCP1502T-33E/CHY; DIGIKEY_PART_NUMBER 150-MCP1502T-33E/CHYCT-ND
Y2: 32.768kHz; ABS07-32.768KHZ-1-T; MANUFACTURER_PART_NUMBER ABS07-32.768KHZ-T; DIGIKEY_PART_NUMBER 535-9542-1-ND

Connections:
3V0_RF_LDO_PG: U12.87 (PG2); also elsewhere on the board
3V3_GPS_LDO_PG: U12.56 (PG0); also elsewhere on the board
3V3_PSU_PG: U12.89 (PG4); also elsewhere on the board
3V3_STM: C21.1, C22.1, C23.1, C24.1, C25.1, C194.1, C195.1, C196.1, C197.1, C198.1, C199.1, R53.1, U12.17 (VDD), U12.30 (VDD__1), U12.39 (VDD__2), U12.52 (VDD__3), U12.62 (VDD__4), U12.72 (VDD__5), U12.84 (VDD__6), U12.95 (VDD__7), U12.108 (VDD__8), U12.121 (VDDIO2), U12.131 (VDD__9), U12.144 (VDD__10); also elsewhere on the board
3V3_STM_USB: C26.1, C28.1, U12.106 (VDDUSB)
5V: C39.1, FB2.2, R51.1, R52.1, U14.6 (VDD); also elsewhere on the board
5V_PSU_PG: U12.88 (PG3), U13.3 (EN/UV); also elsewhere on the board
10MHz_CLK_OUT: U12.75 (PB14); also elsewhere on the board
ANT_BIAS_EN: U12.99 (PC9); also elsewhere on the board
BKP_GPS_PG: U12.55 (PF15); also elsewhere on the board
BKP_STM_PG: U12.54 (PF14); also elsewhere on the board
BUTTON_1: U12.10 (PF0); also elsewhere on the board
BUTTON_2: U12.11 (PF1); also elsewhere on the board
BUTTON_3: U12.12 (PF2); also elsewhere on the board
BUTTON_4: U12.13 (PF3); also elsewhere on the board
BUTTON_5: U12.14 (PF4); also elsewhere on the board
BUTTON_6: U12.15 (PF5); also elsewhere on the board
BUTTON_7: U12.18 (PF6); also elsewhere on the board
CLK_OUT: U12.23 (PH0-OSC_IN); also elsewhere on the board
DISP_BL: U12.5 (PE6); also elsewhere on the board
DISP_CS: U12.60 (PE9); also elsewhere on the board
DISP_DC: U12.46 (PB0); also elsewhere on the board
DISP_EN: U12.112 (PC11); also elsewhere on the board
DISP_RST: U12.102 (PA10); also elsewhere on the board
DISP_TOUCH_INT: U12.19 (PF7); also elsewhere on the board
ENC_A: U12.100 (PA8); also elsewhere on the board
ENC_B: U12.101 (PA9); also elsewhere on the board
ENC_BUTTON: U12.49 (PF11); also elsewhere on the board
ETH_PPS_OUT: U12.135 (PB5); also elsewhere on the board
FAN_PWM: U12.4 (PE5); also elsewhere on the board
FAN_TACH: U12.110 (PA15(JTDI)); also elsewhere on the board
GND: C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C194.2, C195.2, C196.2, C197.2, C198.2, C199.2, Q6.2 (E), Q7.2 (E), R46.2, R47.2, R50.2, R54.2, R233.2, R263.2, U12.16 (VSS), U12.31 (VSSA), U12.38 (VSS__1), U12.51 (VSS__2), U12.61 (VSS__3), U12.71 (VSS__4), U12.83 (VSS__5), U12.94 (VSS__6), U12.107 (VSS__7), U12.120 (VSS__8), U12.130 (VSS__9), U12.143 (VSS__10), U13.8 (GND), U13.11 (GND), U14.2 (GND), U14.3 (GND), U14.5 (GND); also elsewhere on the board
GPS_ANT_OFF_MON: U12.118 (PD4); also elsewhere on the board
GPS_DSEL: U12.123 (PD7); also elsewhere on the board
GPS_EXTINT: U12.122 (PD6); also elsewhere on the board
GPS_PPS: U12.34 (PA0); also elsewhere on the board
GPS_PWR_EN: U12.98 (PC8); also elsewhere on the board
GPS_RST_N: U12.80 (PD11); also elsewhere on the board
GPS_RX: U12.77 (PD8); also elsewhere on the board
GPS_RXD2: U12.115 (PD1); also elsewhere on the board
GPS_SAFEBOOT_N: U12.86 (PD15); also elsewhere on the board
GPS_TP2: U12.96 (PC6); also elsewhere on the board
GPS_TX: U12.78 (PD9); also elsewhere on the board
GPS_TXD2: U12.114 (PD0); also elsewhere on the board
GPS_TXRDY: U12.119 (PD5); also elsewhere on the board
HOLDOVER_ALARM_RELAY: U12.42 (PA6); also elsewhere on the board
I2C_SCL: U12.139 (PB8); also elsewhere on the board
I2C_SDA: U12.140 (PB9); also elsewhere on the board
INA_ALERT_3V3: U12.126 (PG11); also elsewhere on the board
INA_ALERT_3V3_GPS: U12.127 (PG12); also elsewhere on the board
INA_ALERT_3V3_STM: U12.124 (PG9); also elsewhere on the board
INA_ALERT_5V_DISP: U12.125 (PG10); also elsewhere on the board
INA_ALERT_5V_PANEL: U12.53 (PF13); also elsewhere on the board
INA_ALERT_OCXO: U12.129 (PG14); also elsewhere on the board
INA_ALERT_VCC_RB: U12.132 (PG15); also elsewhere on the board
INA_ALERT_V_ANT: U12.128 (PG13); also elsewhere on the board
INA_ALERT_V_POE: U12.93 (PG8); also elsewhere on the board
LAN_RST_N: U12.79 (PD10); also elsewhere on the board
LED_B: U12.85 (PD14); also elsewhere on the board
LED_G: U12.82 (PD13); also elsewhere on the board
LED_R: U12.81 (PD12); also elsewhere on the board
MCU_NRST: U12.25 (~RST); also elsewhere on the board
MUX_SEL: U12.136 (PB6); also elsewhere on the board
NOR_RST_N: U12.63 (PE10); also elsewhere on the board
unnamed: C38.1, R48.2
unnamed: Q6.1 (B), Q7.3 (C), R52.2
unnamed: Q6.3 (C), R51.2, U14.4 (nSHDN)
unnamed: Q7.1 (B), R53.2, R54.1
unnamed: R50.1, U12.138 (BOOT0)
unnamed: C31.1, U12.8 (PC14-OSC32_IN), Y2.2
unnamed: C29.1, U12.9 (PC15-OSC32_OUT), Y2.1
unnamed: C36.1, U12.70 (VCAP)
unnamed: C34.1, U12.142 (VCAP__1)
unnamed: R232.2, R233.1, U12.90 (PG5)
unnamed: R263.1, R264.2, U12.92 (PG7)
unnamed: R46.1, U13.5 (ILIM)
unnamed: C27.1, FB2.1, U13.1 (IN), U13.2 (IN), U13.6 (PGFB)
unnamed: C30.1, R47.1, U13.7 (SET)
OCXO_LDO_PG: U12.57 (PG1); also elsewhere on the board
OCXO_PSU_PG: R232.1; also elsewhere on the board
OCXO_V: U12.37 (PA3); also elsewhere on the board
OCXO_VC: U12.40 (PA4); also elsewhere on the board
PANEL_LED_EN: U12.26 (PC0); also elsewhere on the board
PANEL_LED_FAULT: U12.50 (PF12); also elsewhere on the board
PANEL_LED_PWM: U12.141 (PE0); also elsewhere on the board
PFI: U12.59 (PE8); also elsewhere on the board
POE_KILL: U12.68 (PE15); also elsewhere on the board
POE_LCF: U12.29 (PC3); also elsewhere on the board
POE_NCL: U12.97 (PC7); also elsewhere on the board
POE_NCM: U12.28 (PC2); also elsewhere on the board
POE_PG: R264.1; also elsewhere on the board
PROX_WAKE: U12.22 (PF10); also elsewhere on the board
RB_LOCK: U12.74 (PB13); also elsewhere on the board
RB_OV_DET: U12.2 (PE3); also elsewhere on the board
RB_OV_RESET: U12.117 (PD3); also elsewhere on the board
RB_PSU_PG: U12.91 (PG6); also elsewhere on the board
RB_PWR_EN: U12.137 (PB7); also elsewhere on the board
RB_RS232_CMOS_SW: U12.3 (PE4); also elsewhere on the board
RB_RX: U12.134 (PB4(NJTRST)); also elsewhere on the board
RB_TX: U12.58 (PE7); also elsewhere on the board
RB_VCC_GATE: U12.47 (PB1); also elsewhere on the board
REF_TERM_EN: U12.111 (PC10); also elsewhere on the board
RMII_CRS_DV: U12.43 (PA7); also elsewhere on the board
RMII_MDC: U12.27 (PC1); also elsewhere on the board
RMII_MDIO: U12.36 (PA2); also elsewhere on the board
RMII_REF_CLK: U12.35 (PA1); also elsewhere on the board
RMII_RXD0: U12.44 (PC4); also elsewhere on the board
RMII_RXD1: U12.45 (PC5); also elsewhere on the board
RMII_RXER: U12.69 (PB10); also elsewhere on the board
RMII_TXD0: U12.73 (PB12); also elsewhere on the board
RMII_TXD1: U12.76 (PB15); also elsewhere on the board
RMII_TX_EN: U12.41 (PA5); also elsewhere on the board
RTC_TAMPER: U12.7 (PC13); also elsewhere on the board
SPI_DPOT_CS: U12.116 (PD2); also elsewhere on the board
SPI_MISO: U12.66 (PE13); also elsewhere on the board
SPI_MOSI: U12.67 (PE14); also elsewhere on the board
SPI_NSS: U12.64 (PE11); also elsewhere on the board
SPI_SCK: U12.65 (PE12); also elsewhere on the board
STM_VBAT: C33.1, C35.1, U12.6 (VBAT); also elsewhere on the board
SWCLK: U12.109 (PA14(JTCK/SWCLK)); also elsewhere on the board
SWDIO: U12.105 (PA13(JTMS/SWDIO)); also elsewhere on the board
SWO: U12.133 (PB3(JTDO/TRACESWO)); also elsewhere on the board
USB_D+: U12.104 (PA12); also elsewhere on the board
USB_D-: U12.103 (PA11); also elsewhere on the board
USB_VBUS_SENSE: U12.1 (PE2); also elsewhere on the board
VDDA: C32.1, U12.33 (VDDA), U13.9 (OUTS), U13.10 (OUT); also elsewhere on the board
VREF_3V3: C37.1, R48.1, U12.32 (VREF+), U14.1 (OUT)
V_ANT_EN_FAULT: U12.20 (PF8); also elsewhere on the board
V_DISP_EN_FAULT: U12.21 (PF9); also elsewhere on the board
WDT_EN: U12.113 (PC12); also elsewhere on the board
WDT_KICK: U12.48 (PB2); also elsewhere on the board

Notes on the sheet:
<- 3.7V
<- ~56V
Place close to power pins
Noise Sensitive See Datasheet for Layout
